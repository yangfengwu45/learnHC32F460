# IAR project uart_irq_rx_tx.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_irq_rx_tx.srec
  ILINK.IlinkOutputFile: uart_irq_rx_tx.out
  ILINK.IlinkIcfFile: hc32f46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  group common
    ./: startup_hc32f46x.s
    ../../mcu/common/: system_hc32f46x.c
  group driver
    ../../driver/src/: hc32f46x_clk.c hc32f46x_efm.c
    ../../../../driver/src/: hc32f46x_gpio.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_usart.c hc32f46x_utility.c
  group source
    ../source/: main.c
