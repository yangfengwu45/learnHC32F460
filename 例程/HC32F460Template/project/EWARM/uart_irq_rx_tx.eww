<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uart_irq_rx_tx.ewp</path>
  </project>
  <batchBuild/>
</workspace>


